# Keil uVision project HiTrendtech.uvprojx, settings and files
target HT501x (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: HT501x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT501x
  c include: ..\..\Libraries\CMSIS\CoreSupport\CM0;..\..\Libraries\CMSIS\DeviceSupport;..\..\Libraries\CMSIS\DeviceSupport\inc;..\..\Libraries\HT60xx_StdPeriph_Driver;..\..\Libraries\HT60xx_StdPeriph_Driver\inc;..\..\Users;..\..\Users\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Libraries/CMSIS/DeviceSupport/src/: system_ht6xxx.c
  group Doc
    ../../Documents/: readme.txt
  group Example
    ../../Examples/aes/src/: aes_example.c
    ../../Examples/crc/src/: crc_example.c
    ../../Examples/ecc/src/: ecc_example.c
    ../../Examples/others/src/: example.c
    ../../Examples/flash/src/: flash_example.c
    ../../Examples/random/src/: random_example.c
    ../../Examples/dma/src/: dma_example.c
    ../../Examples/emu/src/: emu_example.c
  group Startup
    ../../Libraries/Startup/Keil/: startup_ht6x1x.s startup_ht6x2x.s startup_ht6x3x.s startup_ht501x.s startup_ht502x.s startup_ht6x2xK.s startup_ht7x2x.s startup_ht503x.s startup_ht633x.s
  group StdPeriphDriver
    ../../Libraries/HT60xx_StdPeriph_Driver/src/: ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_crc.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c ht501x_keyscan.c ht6x3x_emu.c ht50xx_emu.c ht6xxx_wdt.c ht5x3x_frampack.c ht7x2x_fft.c ht7x2x_frampack.c ht5x3x_emuiface.c ht7x2x_emuiface.c ht7xxx_emu.c
  group User
    ../../Users/src/: ht6xxx_it.c main.c ht_gpio.c ht_freertos.c ht_uart.c ht_tmr.c
    ../../FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_CORE
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
target HT502x (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: HT502x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT502x
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target HT503x (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: HT503x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT503x
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
target HT6x1x (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: HT6x1x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT6x1x
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target HT6x2x (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: HT6x2x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT6x2x
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
target HT6x3x (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: HT6x3x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT6x3x
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target HT6x2xK (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: HT6x2xK +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT6x2xK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
target HT633x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT6335 Hitrendtech
  pack: Hitrendtech.HTXXXX_DFP.1.1.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HT633x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT633x
  c include: ..\..\Libraries\CMSIS\CoreSupport\CM3;..\..\Libraries\CMSIS\DeviceSupport;..\..\Libraries\CMSIS\DeviceSupport\inc;..\..\Libraries\HT60xx_StdPeriph_Driver;..\..\Libraries\HT60xx_StdPeriph_Driver\inc;..\..\Users;..\..\Users\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
target HT762x (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: HT762x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT762x
  c include: ..\..\Libraries\CMSIS\CoreSupport\CM0;..\..\Libraries\CMSIS\DeviceSupport;..\..\Libraries\CMSIS\DeviceSupport\inc;..\..\Libraries\HT60xx_StdPeriph_Driver;..\..\Libraries\HT60xx_StdPeriph_Driver\inc;..\..\Users;..\..\Users\inc;..\..\Examples\emu\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
target HT772x (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: HT772x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HT772x
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
