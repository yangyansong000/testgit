# IAR project HiTrendtech.ewp, settings and files
configuration HT6x3x (ARM, debug)
  General.OGChipSelectEditMenu: HT6X3X Hitrendtech HT6X3X
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HT6x3x
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CoreSupport\CM0; ..\..\Libraries\CMSIS\DeviceSupport; ..\..\Libraries\CMSIS\DeviceSupport\inc; ..\..\Libraries\HT60xx_StdPeriph_Driver; ..\..\Libraries\HT60xx_StdPeriph_Driver\inc; ..\..\Users; ..\..\Users\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HT6x3x.bin
  ILINK.IlinkOutputFile: HT6X3X.out
  ILINK.IlinkIcfFile: flashloader\HT6X3X.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration HT6x2x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT6X2X Hitrendtech HT6X2X
  ICCARM.CCDefines: HT6x2x
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT6x2x.bin
  ILINK.IlinkOutputFile: HT6X2X.out
  ILINK.IlinkIcfFile: flashloader\HT6X2X.icf
configuration HT6x1x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT6X1X Hitrendtech HT6X1X
  ICCARM.CCDefines: HT6x1x
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT6x1x.bin
  ILINK.IlinkOutputFile: HT6X1X.out
  ILINK.IlinkIcfFile: flashloader\HT6X1X.icf
configuration HT502x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT502X Hitrendtech HT502X
  ICCARM.CCDefines: HT502x
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT502x.bin
  ILINK.IlinkOutputFile: HT502X.out
  ILINK.IlinkIcfFile: flashloader\HT502X.icf
configuration HT501x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT501X Hitrendtech HT501X
  ICCARM.CCDefines: HT501x
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT501x.bin
  ILINK.IlinkOutputFile: HT501X.out
  ILINK.IlinkIcfFile: flashloader\HT501X.icf
configuration HT6x2xK (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT6X2XK Hitrendtech HT6X2XK
  ICCARM.CCDefines: HT6x2xK
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT6x2xK.bin
  ILINK.IlinkOutputFile: HT6X2XK.out
  ILINK.IlinkIcfFile: flashloader\HT6X2XK.icf
configuration HT503x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT503X Hitrendtech HT503X
  ICCARM.CCDefines: HT503x
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT503x.bin
  ILINK.IlinkOutputFile: HT503X.out
  ILINK.IlinkIcfFile: flashloader\HT503X.icf
configuration HT633x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT633X Hitrendtech HT633X
  ICCARM.CCDefines: HT633x
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CoreSupport\CM3; ..\..\Libraries\CMSIS\DeviceSupport; ..\..\Libraries\CMSIS\DeviceSupport\inc; ..\..\Libraries\HT60xx_StdPeriph_Driver; ..\..\Libraries\HT60xx_StdPeriph_Driver\inc; ..\..\Users; ..\..\Users\inc
  OBJCOPY.OOCOutputFile: HT633x.bin
  ILINK.IlinkOutputFile: HT633X.out
  ILINK.IlinkIcfFile: flashloader\HT633X.icf
configuration HT762x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT762X Hitrendtech HT762X
  ICCARM.CCDefines: HT762x
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT762x.bin
  ILINK.IlinkOutputFile: HT762X.out
  ILINK.IlinkIcfFile: flashloader\HT762X.icf
configuration HT772x (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: HT772X Hitrendtech HT772X
  ICCARM.CCDefines: HT772x
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HT772x.bin
  ILINK.IlinkOutputFile: HT772X.out
  ILINK.IlinkIcfFile: flashloader\HT772X.icf
  group CMSIS
    ../../Libraries/CMSIS/DeviceSupport/src/: system_ht6xxx.c
  group Doc
    ../../Documents/: readme.txt
  group Example
    ../../Examples/aes/src/: aes_example.c
    ../../Examples/crc/src/: crc_example.c
    ../../Examples/dma/src/: dma_example.c
    ../../Examples/ecc/src/: ecc_example.c
    ../../Examples/emu/src/: emu_example.c
    ../../Examples/others/src/: example.c
    ../../Examples/flash/src/: flash_example.c
    ../../Examples/random/src/: random_example.c
  group Startup
    ../../Libraries/Startup/IAR/: startup_ht501x.s startup_ht502x.s startup_ht503x.s startup_ht633x.s startup_ht6x1x.s startup_ht6x2x.s startup_ht6x2xK.s startup_ht6x3x.s startup_ht7x2x.s
  group StdPeriphDriver
    ../../Libraries/HT60xx_StdPeriph_Driver/src/: ht501x_keyscan.c ht50xx_emu.c ht5x3x_emuiface.c ht5x3x_frampack.c ht6x3x_emu.c ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_crc.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c ht6xxx_wdt.c ht7x2x_emuiface.c ht7x2x_fft.c ht7x2x_frampack.c ht7xxx_emu.c
  group User
    ../../Users/src/: ht6xxx_it.c main.c
